# Keil uVision project SmartCar.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.2
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SmartCar +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\CMSIS;..\FWLIB\inc;..\FWLIB\src;..\USER;.\Driver;.\System;.\app;.\Service
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: stm32f10x_it.c main.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group FWlib
    ../FWLIB/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group STARTCODE
    ../CMSIS/: startup_stm32f10x_hd.s
  group Driver
    ./Driver/: gyroscope.c motor_driver.c motor_init.c usart.c street_motor.c iic.c oled.c
  group System
    ./System/: system_core.c
  group Service
    ./Service/: MechanicalArm_Clr.c position_clr.c DataScope_DP.C
  group app
    ./app/: main_app.c
